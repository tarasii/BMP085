# Keil uVision project dht22tocom.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dhttocom
  c flags: Optim=1
  c define: STM32L15XXB_128K USE_STDPERIPH_DRIVER
  c include: ..\STM32L1xx_StdPeriph_Driver\inc;..\Board;.\;..\..\..\..\INC\ST\STM32L1xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_stm32l1xx_md.s main.c system_stm32l1xx.c dht11.c uart.c i2c.c bmp085.c onewire.c 18b20.c leds.c adc.c rtc.c pin.c button.c dac.c
  group New Group
    ../STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c misc.c stm32l1xx_exti.c stm32l1xx_dma.c stm32l1xx_adc.c stm32l1xx_flash.c stm32l1xx_pwr.c stm32l1xx_dac.c stm32l1xx_i2c.c
